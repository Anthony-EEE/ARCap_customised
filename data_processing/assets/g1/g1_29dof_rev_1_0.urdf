Commit message: add 3 finger hand control

File: data_processing/assets/g1/g1_29dof_rev_1_0.urdf (robot description, URDF)
Before this commit: robot g1_29dof_rev_1_0, 39 links, 38 joints
Links:
- link left_rubber_hand: geometry 
- link right_rubber_hand: geometry 
